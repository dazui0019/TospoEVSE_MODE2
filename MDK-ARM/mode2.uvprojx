# Keil uVision project mode2.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mode2 +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe  --bincombined --output=.\elf\@L.bin !L
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --text -c -a -v --output=.\elf\@L.asm !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: GD32F30X_HD,PRINTF_INCLUDE_CONFIG_H
  c include: ..\Drivers\GD32F30x_Firmware_Library_V2.2.0\CMSIS\GD\GD32F30x\Include;..\Drivers\GD32F30x_Firmware_Library_V2.2.0\CMSIS;..\Drivers\GD32F30x_Firmware_Library_V2.2.0\GD32F30x_standard_peripheral\Include;..\CORE\Inc;..\Middlewares\BasicOS;..\BSP\Inc;..\Libraries\printf;..\Libraries\elog;..\Libraries\lwrb;..\Libraries\crc16;..\Libraries\fifo;..\Libraries\datetime;..\Drivers\lcd_drivers;..\Libraries\UGUI;..\Drivers\ws2812b\src;..\Drivers\ws2812b;..\Drivers\ws2812b_port;..\Libraries\utils;..\Drivers\SEGGER_RTT_V810k\RTT;..\Drivers\SEGGER_RTT_V810k\Config
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Objects\mode2.sct
  group CORE
    ../CORE/Src/: gd32f30x_it.c main.c cb_basic_os.c evse_cp.c evse_comm.c evse_relay.c evse_adh.c evse_charge.c evse_ntc.c evse_ac.c evse_rcd.c evse_ui.c FaultHandler.c evse_rgb.c evse_key.c evse_beep.c evse_delay.c evse_cfg.c
  group Libraries/printf
    ../Libraries/printf/: printf.c printf_config.h printf_port.c
  group BSP
    ../BSP/Src/: gd32f303x_start.c drv_uart.c drv_timer.c drv_delay.c drv_spi.c drv_rtc.c drv_flash.c
  group Middlewares/BasicOS
    ../Middlewares/BasicOS/: basic_os.c
    ../Middlewares/BasicOS/port/arm_m0/: cpu.c port_mdk.s
  group Startup
    ../Drivers/GD32F30x_Firmware_Library_V2.2.0/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../Drivers/GD32F30x_Firmware_Library_V2.2.0/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Drivers/GD32F30x_Firmware_Library
    ../Drivers/GD32F30x_Firmware_Library_V2.2.0/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Libraries/elog
    ../Libraries/elog/: elog.c elog_utils.c elog_port.c elog_cfg.h
  group Libraries/lwrb
    ../Libraries/lwrb/: lwrb.c
  group Libraries/crc16
    ../Libraries/crc16/: crc16.c
  group Libraries/fifo
    ../Libraries/fifo/: fifo.c
  group Libraries/datetime
    ../Libraries/datetime/: datetime.c
  group Drivers/lcd
    ../Drivers/lcd_drivers/: GC9A01.c lcd_drv_conf.h lcd_port.c
  group Libraries/ugui
    ../Libraries/UGUI/: ugui.c
  group Drivers/ws2812b
    ../Drivers/ws2812b/: driver_ws2812b.c
    ../Drivers/ws2812b_port/: ws2812b_port.c
  group Libraries/utils
    ../Libraries/utils/: utils.c
  group Drivers/SeggerRTT
    ../Drivers/SEGGER_RTT_V810k/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: Compiler:Event Recorder 1.5.1
